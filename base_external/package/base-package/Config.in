## base_external/package/base-package/Config.in
```kconfig
config BR2_PACKAGE_BASE_PACKAGE
	bool "BASE_PACKAGE"
	help
	  Example of base pakcage
```
